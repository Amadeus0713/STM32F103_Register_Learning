# Keil uVision project LED.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: D:\Keil_v5\ARM\Packs\Keil\STM32F1xx_DFP\2.4.1\Device\Include;D:\Keil_v5\ARM\Packs\ARM\CMSIS\6.3.0\CMSIS\Include;D:\Keil_v5\ARM\CMSIS\6.3.0\CMSIS\Core\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group New Group
    ./: main.c startup_stm32f10x_md.s
